#include<reg51.h>
#include<stdio.h>

sbit X=P1^0;
sbit Y=P1^1;
sbit Z=P1^2;
sbit SOC=P1^3;
sbit ALE=P1^4;
sbit OE=P1^5;
sbit EOC=P1^6;
sbit rs=P3^0;
sbit en=P3^1;


/*P0 -> ADC0808 data output (D0–D7) 
P1 -> ADC control/address (X, Y, Z, SOC, ALE, OE, EOC) 
P2 -> LCD data 
P3 -> LCD control (RS, EN) */

unsigned char adc_data;
char buffer[10];

void delay(unsigned int ms) {
    unsigned int i, j;
    for(i=0; i<ms; i++)
        for(j=0; j<1275; j++);
}

void lcd_data(unsigned char xyz){
	rs=1;
	P2=xyz;
	en=1;
	delay(5);
	en=0;
}

void lcd_cmd(unsigned char xyz){
	rs=0;
	P2=xyz;
	en=1;
	delay(5);
	en=0;
}

void lcd_init() {		
    lcd_cmd(0x38);  
    lcd_cmd(0x0C);  
    lcd_cmd(0x06);  
    lcd_cmd(0x01);  
    delay(2);
}

void lcd_string(char *str){
    while(*str) lcd_data(*str++);
}//Every time you call lcd_string,it loops through each character and calls lcd_data() for that character.
//*str dereferences the pointer, giving the current character.
//In C, a string ends with a null character '\0'.
//So while(*str) means: "Keep looping until the current character is '\0'."

unsigned char start(unsigned char channel){ 
  X = channel & 0x01;
	Y = (channel >> 1) & 0x01;
  Z = (channel >> 2) & 0x01;

	ALE=1;
	delay(1);
	ALE=0;
	SOC=1;
	delay(1);	
	SOC=0;
	
while(EOC==1);
    OE=1;
	  adc_data=P0;
		OE=0;
		return adc_data; 
}

void main(){
	  lcd_init();
	  lcd_cmd(0x80);  //set cursor at first row of LCD
	  lcd_string("Temp:");   
	
	  while(1){
			  unsigned char _data = start(0);

        // Convert ADC value to tempeature Example: ADC=128 -> temp_scaled=251 -> 25.1°C.
        //T(°C)=ADC×500/255
			  unsigned int temp = (_data * 500) / 255; //same project can be used for display voltage
        unsigned char int_part = temp / 10;  //Split TEMP into integer & decimal   
        unsigned char dec_part = temp % 10;     
        //ADC count 0–255 corresponds to 0–5V.
        //Since LM35 outputs 10 mV/°C, at 5V = 5000 mV -> 500 °C max.
        sprintf(buffer, "%d.%d C", int_part, dec_part);
	      lcd_cmd(0xC0);        
		    lcd_string(buffer);
		 
	      delay(100);
	}
}
